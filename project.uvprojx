# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, LFS_CONFIG=lfs_config.h, STM32F429xx
  c misc: -Wno-pointer-bool-conversion -Wno-tautological-pointer-compare -Wno-invalid-source-encoding -Wno-logical-not-parentheses
  c include: rt-thread\components\libc\compilers\common\extension;packages\agile_modbus-latest\inc;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m4;BoardDriver\modbus\slave;BoardDriver\file;packages\syswatch-latest\inc;.;packages\get_irq_priority;rt-thread\components\utilities\ulog\backend;rt-thread\components\utilities\ulog;applications;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;libraries\HAL_Drivers\drv_flash;rt-thread\include;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\stdio;board\CubeMX_Config\Inc;libraries\HAL_Drivers\CMSIS\Include;libraries\HAL_Drivers;rt-thread\components\drivers\include;board;rt-thread\components\fal\inc;rt-thread\components\drivers\include;packages\CanFestival-latest\master402;rt-thread\components\drivers\spi\sfud\inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;packages\agile_modbus-latest\util;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\FlashDB-latest\inc;rt-thread\components\libc\posix\ipc;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\components\drivers\include;packages\CmBacktrace-latest;BoardDriver\drivers;packages\MFBD-latest;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;packages\CanFestival-latest\inc;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\dfs\include;libraries\HAL_Drivers\config;rt-thread\libcpu\arm\common;rt-thread\components\utilities\ymodem;board\ports;BoardDriver\user;rt-thread\components\drivers\include;packages\littlefs-latest
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group agile_modbus
    packages/agile_modbus-latest/src/: agile_modbus_rtu.c agile_modbus.c agile_modbus_tcp.c
    packages/agile_modbus-latest/util/: agile_modbus_slave_util.c
  group agile_modbus\slave
    BoardDriver/modbus/slave/: modbus_slave_common.c modbus_slave2.c registers.c bits.c input_bits.c input_registers.c modbus_slave_key.c modbus_slave1.c
  group APP/Drivers
    board/CubeMX_Config/Src/: dma.c system_stm32f4xx.c stm32f4xx_hal_msp.c usart.c iwdg.c adc.c CubeMX_rtc.c main.c gpio.c CubeMX_can.c spi.c tim.c stm32f4xx_it.c fmc.c
    board/CubeMX_Config/MDK-ARM/: startup_stm32f429xx.s
    board/ports/: spi_flash_init.c
    board/: board.c
  group Applications
    applications/: user_math.c bsp_key.c
  group BoardDriver
    BoardDriver/drivers/: lifter_motor.c monitor.c motor.c
    BoardDriver/file/: filesystem.c ulog_file_be.c
    BoardDriver/user/: user_adc.c user_can.c user_pwm.c
  group CanFestival
    packages/CanFestival-latest/src/: emcy.c canopen_timer.c pdo.c objacces.c timer_rtthread.c can_rtthread.c states.c sdo.c nmtSlave.c sync.c lifegrd.c nmtMaster.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cmb_port.c cmb_flash_log.c cm_backtrace.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    libraries/HAL_Drivers/: drv_can.c drv_sdram.c drv_usart_v2.c drv_spi.c drv_wdt.c drv_common.c drv_tim.c drv_adc.c drv_rtc.c drv_pwm.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_partition.c fal_rtt.c fal.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group FlashDB
    packages/FlashDB-latest/src/: fdb.c fdb_tsdb.c fdb_cmd.c fdb_file.c fdb_kvdb.c fdb_utils.c
  group get_irq_priority
    packages/get_irq_priority/src/: get_irq.c
  group Kernel
    packages/rt_memcpy_cm-latest/: rt_memcpy_rvds.S
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c stm32f4xx_ll_fmc.c
  group littlefs
    packages/littlefs-latest/: lfs_crc.c lfs.c lfs_util.c dfs_lfs.c
  group Master402
    packages/CanFestival-latest/master402/: master402_canopen.c motor_control.c canopen_callback.c master402_od.c
  group mfbd
    packages/MFBD-latest/: mfbd.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group syswatch
    packages/syswatch-latest/src/: syswatch_test.c syswatch.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c file_be.c
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
